# Keil uVision project STM32F4Training.uvprojx, settings and files
target Training (ARM-ADS)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4Training +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F401xx
  c include: .\Users;.\System\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\System\Libraries\CMSIS\Include;.\System\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\System\STM32F4BSP;..\STM32F4Training\System\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\System\FreeRTOS\include;.\System\FreeRTOS\portable\MemMang;.\System\FreeRTOS\portable\RVDS\ARM_CM4F;.\System\FreeRTOS\CMSIS_RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./Users/: main.c
  group FreeRTOS
    ./System/FreeRTOS/: timers.c tasks.c queue.c list.c croutine.c event_groups.c
    ./System/FreeRTOS/portable/MemMang/: heap_2.c
    ./System/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group BoardSupport
    ./System/STM32F4BSP/: DISCO_ADC.c Disco_Button.c Disco_Clock.c Disco_LED.c DISCO_USART.c
  group Libraries
    ./System/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CMSIS
    ./System/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./System/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
